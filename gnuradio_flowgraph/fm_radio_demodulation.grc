options:
  parameters:
    author: baileylamar
    generate_options: qt_gui
    id: default
    output_language: python
    title: fm_demod_fuller
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 91.9*1000000
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '57000'
    offset: '0'
    phase: '0'
    samp_rate: '256000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '51200'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '5'
    taps: '[0.00015769581854408333, 0.00030416845058021643, 0.0005645396551002686, 0.0009323893311120908, 0.0014127448293827362, 0.001996335507363505, 0.0026562552997163283, 0.0033461372266224676, 0.004000926057954679, 0.004540792337650156, 0.00487828318620048, 0.004928136090512238, 0.004619502464917118, 0.0039086636569665705, 0.0027906306324976113, 0.0013080365394150262, -0.0004446132136637423, -0.002323672294597792, -0.00414524130262263, -0.005701976923580897, -0.006785416530174552, -0.007212468008371441, -0.006853047900064047, -0.005654750430507404, -0.003661714251401963, -0.0010232214910764453, 0.0020096335137726913, 0.005101204261006466, 0.00786171225018415, 0.009889139853281536, 0.010818186173383409, 0.010371570831913793, 0.008407103961282142, 0.0049544958951074705, 0.00023601776893431782, -0.005333134464506076, -0.011167146635604024, -0.01655396505121126, -0.020719063747097807, -0.022902405836779983, -0.02244161663580391, -0.018851694554617902, -0.011892654362075906, -0.00161621817599725, 0.011614536785395717, 0.027136763913230208, 0.04403069726426082, 0.0611910505646848, 0.07742023780487391, 0.09153469929019227, 0.10247322166379923, 0.1093963135680822, 0.11176577374722303, 0.1093963135680822, 0.10247322166379923, 0.09153469929019227, 0.07742023780487391, 0.0611910505646848, 0.04403069726426082, 0.027136763913230208, 0.011614536785395717, -0.00161621817599725, -0.011892654362075906, -0.018851694554617902, -0.02244161663580391, -0.022902405836779983, -0.020719063747097807, -0.01655396505121126, -0.011167146635604024, -0.005333134464506076, 0.00023601776893431782, 0.0049544958951074705, 0.008407103961282142, 0.010371570831913793, 0.010818186173383409, 0.009889139853281536, 0.00786171225018415, 0.005101204261006466, 0.0020096335137726913, -0.0010232214910764453, -0.003661714251401963, -0.005654750430507404, -0.006853047900064047, -0.007212468008371441, -0.006785416530174552, -0.005701976923580897, -0.00414524130262263, -0.002323672294597792, -0.0004446132136637423, 0.0013080365394150262, 0.0027906306324976113, 0.0039086636569665705, 0.004619502464917118, 0.004928136090512238, 0.00487828318620048, 0.004540792337650156, 0.004000926057954679, 0.0033461372266224676, 0.0026562552997163283, 0.001996335507363505, 0.0014127448293827362, 0.0009323893311120908, 0.0005645396551002686, 0.00030416845058021643, 0.00015769581854408333]'
    type: fff
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: |-
      [-0.003677318361334877116347596981427159335,
      -0.006330787955452201777595266918297056691,
       0.002038598702565987564466754022873828944,
       0.007559432187724498750092116949872433906,
       0.000262074396325791682087202882911469715,
      -0.007810473841907071904100412496063654544,
      -0.002744117212641476819673380660447037371,
       0.006929110371959625036542007592288427986,
       0.004800346584351066273055330668739770772,
      -0.005092660091510493348965216142687495449,
      -0.0058747865213276666968011952008055232,
       0.002810377421078114404395797976121684769,
       0.005654975909595875635527129077217978192,
      -0.000815438770537360840123808358725909784,
      -0.004219813232330315785900687330922664842,
      -0.000134255927165474639147293989260845137,
       0.002089252807171384195006336170763461269,
      -0.000500831111872777185421712342616729075,
      -0.00014459614520262491698873730250340941, 
       0.002822350932033291636552574388474567968,
      -0.000577157967493653351748195134973684617,
      -0.006367955522052503453123151189174677711,
      -0.00082652884116437392528903282951091569, 
       0.010130456161269807760505479166113218525,
       0.004820840819444534644522271094047027873,
      -0.012738859959845376737530564525968657108,
      -0.01120280581905666247855002382038946962, 
       0.012773860844898591790363973075272951974,
       0.019017700384941420982398696537529758643,
      -0.009149314569703404648182143432677548844,
      -0.026665902131523776252830515431924141012,
       0.001465060267634880637049876739297360473,
       0.032196357725622543055621349594730418175,
       0.009766216055822094649352393957997264806,
      -0.033732359230695910246033974999591009691,
      -0.0230918779688857427057069315878834459,
       0.029935036079551370635787321816678741015,
       0.036320538310449235197552297904621809721,
      -0.020391565348257267159537420297965581995,
      -0.046923776262577168716383368973765755072,
       0.005825002604098248118469349776660237694,
       0.052557522747210733138345517545531038195,
       0.011940055494185707746224167635773483198,
      -0.051586692997574297436802481797712971456,
      -0.030265363010205839633393054555199341848,
       0.043488786395703499243481360281293746084,
       0.04618814859967432240317464220424881205,
      -0.029035314348224379454865839988997322507,
      -0.057007870927005294126033163593092467636,
       0.010199279950094468707999517675943934591,
       0.060839675583126473501494047013693489134,
       0.010199279950094468707999517675943934591,
      -0.057007870927005294126033163593092467636,
      -0.029035314348224379454865839988997322507,
       0.04618814859967432240317464220424881205,
       0.043488786395703499243481360281293746084,
      -0.030265363010205839633393054555199341848,
      -0.051586692997574297436802481797712971456,
       0.011940055494185707746224167635773483198,
       0.052557522747210733138345517545531038195,
       0.005825002604098248118469349776660237694,
      -0.046923776262577168716383368973765755072,
      -0.020391565348257267159537420297965581995,
       0.036320538310449235197552297904621809721,
       0.029935036079551370635787321816678741015,
      -0.0230918779688857427057069315878834459,
      -0.033732359230695910246033974999591009691,
       0.009766216055822094649352393957997264806,
       0.032196357725622543055621349594730418175,
       0.001465060267634880637049876739297360473,
      -0.026665902131523776252830515431924141012,
      -0.009149314569703404648182143432677548844,
       0.019017700384941420982398696537529758643,
       0.012773860844898591790363973075272951974,
      -0.01120280581905666247855002382038946962,
      -0.012738859959845376737530564525968657108,
       0.004820840819444534644522271094047027873,
       0.010130456161269807760505479166113218525,
      -0.00082652884116437392528903282951091569,
      -0.006367955522052503453123151189174677711,
      -0.000577157967493653351748195134973684617,
       0.002822350932033291636552574388474567968,
      -0.00014459614520262491698873730250340941,
      -0.000500831111872777185421712342616729075,
       0.002089252807171384195006336170763461269,
      -0.000134255927165474639147293989260845137,
      -0.004219813232330315785900687330922664842,
      -0.000815438770537360840123808358725909784,
       0.005654975909595875635527129077217978192,
       0.002810377421078114404395797976121684769,
      -0.0058747865213276666968011952008055232,
      -0.005092660091510493348965216142687495449,
       0.004800346584351066273055330668739770772,
       0.006929110371959625036542007592288427986,
      -0.002744117212641476819673380660447037371,
      -0.007810473841907071904100412496063654544,
       0.000262074396325791682087202882911469715,
       0.007559432187724498750092116949872433906,
       0.002038598702565987564466754022873828944,
      -0.006330787955452201777595266918297056691,
      -0.003677318361334877116347596981427159335]
    type: fff
  states: {}
- name: fir_filter_xxx_2
  id: fir_filter_xxx
  parameters:
    decim: '16'
    taps: |-
      [-0.00233960321583848770282676454712600389, 
      -0.002902671715079740543535846697409397166,
      -0.003431161407779324910155560601765500905,
      -0.003918303360651304544093331827525616973,
      -0.004357390173214592890560403759536711732,
      -0.004741845684563970354796769157701419317,
      -0.005065295586294856454434576420453595347,
      -0.005321638172616771633727239532163366675,
      -0.005505114440550481699765406062851980096,
      -0.005610376744014902022916757573511858936,
      -0.005632555205824941318981657900621939916,
      -0.005567321101253352999549406376900151372,
      -0.005410946445885034435108185135732128401,
      -0.00516035904889736250084064650422988052, 
      -0.004813192330420222424247622683424197021,
      -0.004367829247934343350756591917161131278,
      -0.003823439731304488411328668107103112561,
      -0.003180011088474768692763161581638087227,
      -0.002438370913413447343270901157552543737,
      -0.001600202103855555236730512369547341223,
      -0.000668049677904499882713507119547102775,
       0.000354680835265016073613170144440687181,
       0.001463733565498064222165641723449880374,
       0.002654021074909210242687152003782102838,
       0.003919651682517755544865600825232831994,
       0.005253965193862300542271270842320518568,
       0.006649576795130197719163600567071625846,
       0.008098428779005944350144474697117402684,
       0.00959184967990429210304981211265840102,
       0.011120620310586557671905794109079579357,
       0.012675046111406422857936782122578733834,
       0.014245035148560911478221591153214831138,
       0.015820181029656283505646641174280375708,
       0.017389849944480971488669496238799183629,
       0.018943270986862773691550287935569940601,
       0.020469628870523497166100668209764990024,
       0.021958158118517107776357377701970108319,
       0.023398237782544940854823067866163910367,
       0.024779485735557705422538177231217559893,
       0.026091851578754376994595531868981197476,
       0.027325707212452032823790659676888026297,
       0.0284719341393109039162201412409558543,
       0.029522006597838781893905490960605675355,
       0.030468069663717338435571235777388210408,
       0.031303011505836905725708163572562625632,
       0.032020529042483120152340347885910887271,
       0.032615186310237312405924114955269033089,
       0.033082464933080701907641696379869244993,
       0.033418806161100128582219781492312904447,
       0.033621644036150782897109934310719836503,
       0.033689429334832828033530205402712454088,
       0.033621644036150782897109934310719836503,
       0.033418806161100128582219781492312904447,
       0.033082464933080701907641696379869244993,
       0.032615186310237312405924114955269033089,
       0.032020529042483120152340347885910887271,
       0.031303011505836905725708163572562625632,
       0.030468069663717338435571235777388210408,
       0.029522006597838781893905490960605675355,
       0.0284719341393109039162201412409558543,
       0.027325707212452032823790659676888026297,
       0.026091851578754376994595531868981197476,
       0.024779485735557705422538177231217559893,
       0.023398237782544940854823067866163910367,
       0.021958158118517107776357377701970108319,
       0.020469628870523497166100668209764990024,
       0.018943270986862773691550287935569940601,
       0.017389849944480971488669496238799183629,
       0.015820181029656283505646641174280375708,
       0.014245035148560911478221591153214831138,
       0.012675046111406422857936782122578733834,
       0.011120620310586557671905794109079579357,
       0.00959184967990429210304981211265840102,
       0.008098428779005944350144474697117402684,
       0.006649576795130197719163600567071625846,
       0.005253965193862300542271270842320518568,
       0.003919651682517755544865600825232831994,
       0.002654021074909210242687152003782102838,
       0.001463733565498064222165641723449880374,
       0.000354680835265016073613170144440687181,
      -0.000668049677904499882713507119547102775,
      -0.001600202103855555236730512369547341223,
      -0.002438370913413447343270901157552543737,
      -0.003180011088474768692763161581638087227,
      -0.003823439731304488411328668107103112561,
      -0.004367829247934343350756591917161131278,
      -0.004813192330420222424247622683424197021,
      -0.00516035904889736250084064650422988052,
      -0.005410946445885034435108185135732128401,
      -0.005567321101253352999549406376900151372,
      -0.005632555205824941318981657900621939916,
      -0.005610376744014902022916757573511858936,
      -0.005505114440550481699765406062851980096,
      -0.005321638172616771633727239532163366675,
      -0.005065295586294856454434576420453595347,
      -0.004741845684563970354796769157701419317,
      -0.004357390173214592890560403759536711732,
      -0.003918303360651304544093331827525616973,
      -0.003431161407779324910155560601765500905,
      -0.002902671715079740543535846697409397166,-0.00233960321583848770282676454712600389]
    type: fff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '8'
    samp_rate: samp_rate
    taps: '[0.00015769581854408333, 0.00030416845058021643, 0.0005645396551002686, 0.0009323893311120908, 0.0014127448293827362, 0.001996335507363505, 0.0026562552997163283, 0.0033461372266224676, 0.004000926057954679, 0.004540792337650156, 0.00487828318620048, 0.004928136090512238, 0.004619502464917118, 0.0039086636569665705, 0.0027906306324976113, 0.0013080365394150262, -0.0004446132136637423, -0.002323672294597792, -0.00414524130262263, -0.005701976923580897, -0.006785416530174552, -0.007212468008371441, -0.006853047900064047, -0.005654750430507404, -0.003661714251401963, -0.0010232214910764453, 0.0020096335137726913, 0.005101204261006466, 0.00786171225018415, 0.009889139853281536, 0.010818186173383409, 0.010371570831913793, 0.008407103961282142, 0.0049544958951074705, 0.00023601776893431782, -0.005333134464506076, -0.011167146635604024, -0.01655396505121126, -0.020719063747097807, -0.022902405836779983, -0.02244161663580391, -0.018851694554617902, -0.011892654362075906, -0.00161621817599725, 0.011614536785395717, 0.027136763913230208, 0.04403069726426082, 0.0611910505646848, 0.07742023780487391, 0.09153469929019227, 0.10247322166379923, 0.1093963135680822, 0.11176577374722303, 0.1093963135680822, 0.10247322166379923, 0.09153469929019227, 0.07742023780487391, 0.0611910505646848, 0.04403069726426082, 0.027136763913230208, 0.011614536785395717, -0.00161621817599725, -0.011892654362075906, -0.018851694554617902, -0.02244161663580391, -0.022902405836779983, -0.020719063747097807, -0.01655396505121126, -0.011167146635604024, -0.005333134464506076, 0.00023601776893431782, 0.0049544958951074705, 0.008407103961282142, 0.010371570831913793, 0.010818186173383409, 0.009889139853281536, 0.00786171225018415, 0.005101204261006466, 0.0020096335137726913, -0.0010232214910764453, -0.003661714251401963, -0.005654750430507404, -0.006853047900064047, -0.007212468008371441, -0.006785416530174552, -0.005701976923580897, -0.00414524130262263, -0.002323672294597792, -0.0004446132136637423, 0.0013080365394150262, 0.0027906306324976113, 0.0039086636569665705, 0.004619502464917118, 0.004928136090512238, 0.00487828318620048, 0.004540792337650156, 0.004000926057954679, 0.0033461372266224676, 0.0026562552997163283, 0.001996335507363505, 0.0014127448293827362, 0.0009323893311120908, 0.0005645396551002686, 0.00030416845058021643, 0.00015769581854408333]'
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: '16000'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: soapy_rtlsdr_source_2
  id: soapy_rtlsdr_source
  parameters:
    center_freq: center_freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', fir_filter_xxx_0, '0']
- [analog_quadrature_demod_cf_0, '0', fir_filter_xxx_1, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', fir_filter_xxx_2, '0']
- [fir_filter_xxx_0, '0', audio_sink_0, '0']
- [fir_filter_xxx_1, '0', blocks_multiply_xx_0, '0']
- [fir_filter_xxx_2, '0', qtgui_time_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [soapy_rtlsdr_source_2, '0', freq_xlating_fir_filter_xxx_0, '0']
- [soapy_rtlsdr_source_2, '0', qtgui_freq_sink_x_0, '0']
- [soapy_rtlsdr_source_2, '0', qtgui_time_sink_x_0, '0']
- [soapy_rtlsdr_source_2, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
