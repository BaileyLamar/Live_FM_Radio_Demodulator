options:
  parameters:
    author: baileylamar
    generate_options: qt_gui
    id: default
    output_language: python
    title: fm_demod_fuller
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 91.9*1000000
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '51200'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '5'
    taps: '[0.00015769581854408333, 0.00030416845058021643, 0.0005645396551002686, 0.0009323893311120908, 0.0014127448293827362, 0.001996335507363505, 0.0026562552997163283, 0.0033461372266224676, 0.004000926057954679, 0.004540792337650156, 0.00487828318620048, 0.004928136090512238, 0.004619502464917118, 0.0039086636569665705, 0.0027906306324976113, 0.0013080365394150262, -0.0004446132136637423, -0.002323672294597792, -0.00414524130262263, -0.005701976923580897, -0.006785416530174552, -0.007212468008371441, -0.006853047900064047, -0.005654750430507404, -0.003661714251401963, -0.0010232214910764453, 0.0020096335137726913, 0.005101204261006466, 0.00786171225018415, 0.009889139853281536, 0.010818186173383409, 0.010371570831913793, 0.008407103961282142, 0.0049544958951074705, 0.00023601776893431782, -0.005333134464506076, -0.011167146635604024, -0.01655396505121126, -0.020719063747097807, -0.022902405836779983, -0.02244161663580391, -0.018851694554617902, -0.011892654362075906, -0.00161621817599725, 0.011614536785395717, 0.027136763913230208, 0.04403069726426082, 0.0611910505646848, 0.07742023780487391, 0.09153469929019227, 0.10247322166379923, 0.1093963135680822, 0.11176577374722303, 0.1093963135680822, 0.10247322166379923, 0.09153469929019227, 0.07742023780487391, 0.0611910505646848, 0.04403069726426082, 0.027136763913230208, 0.011614536785395717, -0.00161621817599725, -0.011892654362075906, -0.018851694554617902, -0.02244161663580391, -0.022902405836779983, -0.020719063747097807, -0.01655396505121126, -0.011167146635604024, -0.005333134464506076, 0.00023601776893431782, 0.0049544958951074705, 0.008407103961282142, 0.010371570831913793, 0.010818186173383409, 0.009889139853281536, 0.00786171225018415, 0.005101204261006466, 0.0020096335137726913, -0.0010232214910764453, -0.003661714251401963, -0.005654750430507404, -0.006853047900064047, -0.007212468008371441, -0.006785416530174552, -0.005701976923580897, -0.00414524130262263, -0.002323672294597792, -0.0004446132136637423, 0.0013080365394150262, 0.0027906306324976113, 0.0039086636569665705, 0.004619502464917118, 0.004928136090512238, 0.00487828318620048, 0.004540792337650156, 0.004000926057954679, 0.0033461372266224676, 0.0026562552997163283, 0.001996335507363505, 0.0014127448293827362, 0.0009323893311120908, 0.0005645396551002686, 0.00030416845058021643, 0.00015769581854408333]'
    type: fff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '8'
    samp_rate: samp_rate
    taps: '[0.00015769581854408333, 0.00030416845058021643, 0.0005645396551002686, 0.0009323893311120908, 0.0014127448293827362, 0.001996335507363505, 0.0026562552997163283, 0.0033461372266224676, 0.004000926057954679, 0.004540792337650156, 0.00487828318620048, 0.004928136090512238, 0.004619502464917118, 0.0039086636569665705, 0.0027906306324976113, 0.0013080365394150262, -0.0004446132136637423, -0.002323672294597792, -0.00414524130262263, -0.005701976923580897, -0.006785416530174552, -0.007212468008371441, -0.006853047900064047, -0.005654750430507404, -0.003661714251401963, -0.0010232214910764453, 0.0020096335137726913, 0.005101204261006466, 0.00786171225018415, 0.009889139853281536, 0.010818186173383409, 0.010371570831913793, 0.008407103961282142, 0.0049544958951074705, 0.00023601776893431782, -0.005333134464506076, -0.011167146635604024, -0.01655396505121126, -0.020719063747097807, -0.022902405836779983, -0.02244161663580391, -0.018851694554617902, -0.011892654362075906, -0.00161621817599725, 0.011614536785395717, 0.027136763913230208, 0.04403069726426082, 0.0611910505646848, 0.07742023780487391, 0.09153469929019227, 0.10247322166379923, 0.1093963135680822, 0.11176577374722303, 0.1093963135680822, 0.10247322166379923, 0.09153469929019227, 0.07742023780487391, 0.0611910505646848, 0.04403069726426082, 0.027136763913230208, 0.011614536785395717, -0.00161621817599725, -0.011892654362075906, -0.018851694554617902, -0.02244161663580391, -0.022902405836779983, -0.020719063747097807, -0.01655396505121126, -0.011167146635604024, -0.005333134464506076, 0.00023601776893431782, 0.0049544958951074705, 0.008407103961282142, 0.010371570831913793, 0.010818186173383409, 0.009889139853281536, 0.00786171225018415, 0.005101204261006466, 0.0020096335137726913, -0.0010232214910764453, -0.003661714251401963, -0.005654750430507404, -0.006853047900064047, -0.007212468008371441, -0.006785416530174552, -0.005701976923580897, -0.00414524130262263, -0.002323672294597792, -0.0004446132136637423, 0.0013080365394150262, 0.0027906306324976113, 0.0039086636569665705, 0.004619502464917118, 0.004928136090512238, 0.00487828318620048, 0.004540792337650156, 0.004000926057954679, 0.0033461372266224676, 0.0026562552997163283, 0.001996335507363505, 0.0014127448293827362, 0.0009323893311120908, 0.0005645396551002686, 0.00030416845058021643, 0.00015769581854408333]'
    type: ccc
  states: {}
- name: soapy_rtlsdr_source_2
  id: soapy_rtlsdr_source
  parameters:
    center_freq: center_freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', fir_filter_xxx_0, '0']
- [fir_filter_xxx_0, '0', audio_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [soapy_rtlsdr_source_2, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
